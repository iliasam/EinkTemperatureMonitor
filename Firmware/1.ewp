# IAR project 1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD_VL; HAVE_CONFIG_H
  ICCARM.IExtraOptions: --diag_warning Pe191; --diag_suppress Pe191; --diag_suppress Pa050
  ICCARM.CCIncludePath2: .\inc; ..\inc; src\calculation; src; src\display; src\communication; src\communication\mavlink; src\communication\mavlink\mav_home
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 1.hex
  ILINK.IlinkOutputFile: 1.out
  ILINK.IlinkIcfFile: stm32f103C8T6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group src
    src/: config.h delay_us_timer.c gpio_common.c hardware.c main.c main.h stm32f10x_it.c
  group src/CMSIS
    src/CMSIS/: system_stm32f10x.c
  group src/communication
    src/communication/: fifo_functions.c mavlink_handling.c uart_handling.c
  group src/display
    src/display/: display_functions.c display_spi.c draw_monitor.c GxEPD2_154_D67.c
  group src/inc
    src/inc/: stm32f10x.h stm32f10x_conf.h stm32f10x_it.h system_stm32f10x.h
  group src/startup
    src/startup/: startup_stm32f10x_md_vl.s
  group src/StdPeriphLib
    src/StdPeriphLib/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
